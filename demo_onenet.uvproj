# Keil uVision project demo_onenet.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8G1K08 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x03FF) IROM(0-0x1FF8) CLOCK(35000000)
  output: demo_onenet +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\bsp
  group Source Group 1
    ./: STARTUP.A51 main.c Delay.c Delay.h uart.c uart.h STC8G.h
